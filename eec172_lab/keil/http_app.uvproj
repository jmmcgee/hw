# Keil uVision project http_app.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MB9BF568N Spansion
  cpu: IRAM(0x20038000-0x20047FFF) IRAM2(0x1FFF0000-0x1FFFFFFF) IROM(0x00000000-0x000FFFFF) IROM2(0x200C0000-0x200C7FFF) CLOCK(4000000) CPUTYPE("Cortex-M4") FPU2
  output: http_app
  c flags: Optim=1
  c include: ..\common;..\App;..\Lib\BSP\driver;..\Lib\rsi_wifi_apis\core\include;..\Lib\rsi_wifi_apis\ref_apps\include;..\Lib\rsi_wifi_apis\hal\include;..\Lib\rsi_wifi_apis\intf\spi\include;..\Lib\rsi_wifi_apis\hal\SPI;..\Lib\BSP\driver\exint;..\Lib\BSP\driver\dt;..\Lib\BSP\driver\mfs;..\Lib\BSP\driver\gpio;..\Lib\rsi_wifi_apis;..\Lib\WIfi_Class;..\Lib\WyzBee_i2c;..\Lib\WyzBee_gpio;..\Lib\WyzBee_timer;..\Lib\WyzBee_SPI;..\Lib\WyzBee_oled;..\Lib\WyzBee_ext
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x2003c000 size 0x80000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: http_app.sct
  group common
    ./: startup_mb9bf56x.s
    ../common/: system_mb9abxxx.c
  group App
    ../App/: main.cpp remote.cpp remote.h
  group lib\rsi\wifi
    ../Lib/rsi_wifi_apis/core/src/: rsi_api.c rsi_band.c rsi_bg_scan.c rsi_bootup_config.c rsi_build_frame_descriptor.c rsi_bytes_sent_count.c rsi_cfg_enable.c rsi_cfg_get.c rsi_cfg_save.c rsi_debug_prints.c rsi_disconnect.c rsi_dns_query.c rsi_dns_server.c rsi_execute_cmd.c rsi_gpio_config.c rsi_ht_caps.c rsi_http_get.c rsi_http_post.c rsi_init.c rsi_interrupt_handler.c rsi_ip_param_set.c rsi_ipv6_param_set.c rsi_join.c rsi_json_create.c rsi_json_erase_file.c rsi_lib_util.c rsi_load_web_page.c rsi_ltcp_conn_status.c rsi_module_soft_reset.c rsi_multicast.c rsi_multicast_filter.c rsi_oper_mode.c rsi_p2p_config.c rsi_per_mode.c rsi_per_stats.c rsi_ping_request.c rsi_power_mode.c rsi_psk.c rsi_query_conn_status.c rsi_query_fw_version.c rsi_query_go_parms.c rsi_query_mac_address.c rsi_query_net_parms.c rsi_query_rssi.c rsi_query_snr.c rsi_register_interrupt_irq.c rsi_rejoin_params.c rsi_roam_params.c rsi_scan.c rsi_select_antenna.c rsi_send_boot_insn.c rsi_send_data.c rsi_send_ludp_data.c rsi_send_raw_data.c rsi_send_url_rsp.c rsi_send_websocket_data.c rsi_set_ap_config.c rsi_set_certificate.c rsi_set_eap.c rsi_set_mac_addr.c rsi_set_region.c rsi_set_region_ap.c rsi_set_wepkey.c rsi_sleep_timer.c rsi_snmp_enable.c rsi_snmp_get_next_rsp.c rsi_snmp_get_rsp.c rsi_snmp_trap.c rsi_socket.c rsi_socket_close.c rsi_sys_init.c rsi_user_store_config.c rsi_web_fields.c rsi_webpage_clear_files.c rsi_webpage_erase_file.c rsi_wireless_fwupgrade.c rsi_wmm_ps.c rsi_wps_method.c
    ../Lib/rsi_wifi_apis/ref_apps/src/: rsi_buildHttpExtendedHeader.c rsi_config_init.c rsi_app_util.c
    ../Lib/rsi_wifi_apis/: timetick.c delay.c
  group lib\rsi\hal
    ../Lib/rsi_wifi_apis/hal/src/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_timers.c
    ../Lib/rsi_wifi_apis/intf/spi/src/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
    ../Lib/rsi_wifi_apis/hal/SPI/: spi.c
  group WiFi_class
    ../Lib/WIfi_Class/: WyzBeeWiFi.c
  group BSP
    ../Lib/BSP/driver/mfs/: mfs.c
    ../Lib/BSP/driver/: interrupts.c pdl.c
    ../Lib/BSP/driver/exint/: exint.c
    ../Lib/WIfi_Class/: variant.c
    ../Lib/BSP/driver/dt/: dt.c
  group WyzBee_i2c
    ../Lib/WyzBee_i2c/: WyzBee_i2c.c
  group WyzBee_gpio
    ../Lib/WyzBee_gpio/: WyzBee_gpio.c
  group WyzBee_timer
    ../Lib/WyzBee_timer/: WyzBee_timer.c
  group WyzBee_oled
    ../Lib/WyzBee_oled/: Adafruit_GFX.cpp Adafruit_SSD1351.cpp SPI_OLED.cpp
  group WyzBee_SPI
    ../Lib/WyzBee_SPI/: WyzBee_spi.c
  group WyzBee_extInt
    ../Lib/WyzBee_ext/: WyzBee_ext.c
